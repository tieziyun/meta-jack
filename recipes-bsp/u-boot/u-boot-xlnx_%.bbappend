# No U-Boot overrides needed for PYNQ-Z2.
# Distro boot (CONFIG_DISTRO_DEFAULTS=y in xilinx_zynq_virt_defconfig) handles
# SD card boot via boot.scr automatically.
