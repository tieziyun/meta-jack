FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://xdp-bpf.cfg"
